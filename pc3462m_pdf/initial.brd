# Allegro board initial.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_4_5_FPGA: length 2.8
  TOP w0.15: TP18.1 102.79,82.75 103.29,83.25 R31.2
CLK_4_5_MAIN: length 8.7
  TOP w0.15: R30.2 104.33,81.62 103,80.28 103,79.25 102.1,78.35 100.2,78.35 99.08,77.23 U3.7
CLK_99: length 12.2
  TOP w0.15: U3.8 v1(96.82,77.87) ; v1(89.03,78.22) R3.2 84.7,77.25 82.53,79.41 U10.3 81.23,80.69
CLK_99_S: length 2.8
  TOP w0.15: R5.2 TP12.1
CLK_EC_RTM: length 32.2
  TOP w0.15: TP13.1 121.84,70.22 U14.5 121.9,72.35 121.9,73.15 122.7,73.95 125.3,73.95 128.1,71.15 133.3,71.15 134.2,72.05 134.2,74.05 133.2,75.05 133.2,75.37 133.43,75.6 U5.2 134.85,75.6 135.1,75.85 135.1,76.84 136.02,77.75 U8.1 136.65,77.75 137.5,78.6 137.5,80.16 136.65,81.02 U4.7
CLK_EC_RTM_N: length 3.3
  TOP w0.15: v1(144.7,79.95) 144.24,79.48 R273.1 142.8,79.48 142.54,79.75 U4.1
CLK_EC_RTM_P: length 3.3
  TOP w0.15: v1(144.7,80.75) 144.24,81.22 R273.2 142.8,81.22 142.6,81.02 U4.2
DIV2: length 2
  TOP w0.15: R1.2 99.37,74.75 99.31,74.69 U3.3
DRIVE_ST: length 12.4
  TOP w0.15: U3.11 96.52,79.77 95.8,79.05 95.8,71.89 PL1.2
ENABLE: length 3.1
  TOP w0.15: 121.06,109.15 v1(122.1,109.15) 123.21,109.15 U32.5 ; U31.2 v1(147,13.85)
ESD_SEGMENT_1: length 15.2
  TOP w1: 144.6,0.75 144.6,2.85 140.5,6.95 135.78,6.95 R274.2
ESD_SEGMENT_2: length 4.3
  TOP w1: R275.2 137.95,0.8
ESD_SEGMENT_3: length 4.4
  TOP w1: R274.1 114.98,0.77
FAILURE_LED: length 4.6
  TOP w0.15: DS1.2 v1(15.67,3.42) ; R143.1 134.47,105.15 134.21,105.41 U32.9 v1(131.66,105.41)
FAST_CLK_FPGA_N: length 1.4
  TOP w0.15: v1(82.5,86.95) 82.27,86.72 U13.7
FAST_CLK_FPGA_P: length 1.4
  TOP w0.15: U13.6 82.27,87.98 v1(82.5,87.75)
FAST_DATA_N: length 3.5
  TOP w0.15: U17.20 44.49,97.6 R67.1 45.84,98.22 v1(46.3,97.75)
FAST_DATA_P: length 3.5
  TOP w0.15: v1(46.3,96.95) 45.84,96.48 R67.2 44.49,97.1 U17.19
FPGA_F0: length 1.3
  TOP w0.15: U3.12 v1(96.76,80.41)
FPGA_F1: length 1.5
  TOP w0.15: U3.13 99.19,81.04 v1(99.5,81.35)
FPGA_F2: length 0.8
  TOP w0.15: U3.14 v1(98.1,82.45)
FPGA_F3: length 1.6
  TOP w0.15: v1(94,82.4) 93.28,81.68 U3.15
FPGA_F4: length 1.3
  TOP w0.15: U3.16 v1(93.99,81.04)
FPGA_F5: length 1.9
  TOP w0.15: U3.17 v1(94.64,80.41)
FPGA_F6: length 2.7
  TOP w0.15: U3.18 v1(95.38,79.77)
FPGA_R0: length 1.7
  TOP w0.15: v1(94.2,76.45) 93.71,75.96 U3.24
FPGA_R1: length 1.5
  TOP w0.15: U3.25 v1(94.18,75.33)
FPGA_R2: length 1.7
  TOP w0.15: v1(94.2,74.25) 93.76,74.69 U3.26
FPGA_R3: length 1.3
  TOP w0.15: U3.27 v1(91.41,74.06)
FPGA_R4: length 0.7
  TOP w0.15: U3.28 v1(92.7,72.75)
FPGA_R5: length 2.1
  TOP w0.15: U3.1 99.13,73.42 v1(99.9,72.65)
FPGA_R6: length 2.9
  TOP w0.15: U3.2 99.19,74.06 99.8,73.45 v1(100.7,73.45)
FPGA_SPARE_IN1_I_N: length 3
  TOP w0.15: R82.2 32.44,9.15 v1(33.4,9.15) 34.34,9.15
  BOTTOM w0.15: 34.34,9.15 v1(33.4,9.15)
FPGA_SPARE_IN1_I_P: length 3
  TOP w0.15: 34.34,7.15 v1(33.4,7.15) 32.44,7.15 R82.1
  BOTTOM w0.15: 34.34,7.15 v1(33.4,7.15)
FPGA_SPARE_IN1_N: length 3.3
  TOP w0.15: U18.7 v1(45.76,8.79) 46.57,8.79 R96.2
  BOTTOM w0.15: U18.7 v1(45.76,8.79)
FPGA_SPARE_IN1_P: length 3.3
  TOP w0.15: U18.6 v1(45.76,7.52) 46.57,7.52 R96.1
  BOTTOM w0.15: U18.6 v1(45.76,7.52)
FPGA_SPARE_IN2_I_N: length 3
  TOP w0.15: R83.2 32.44,20.65 v1(33.4,20.65) 34.34,20.65
  BOTTOM w0.15: 34.34,20.65 v1(33.4,20.65)
FPGA_SPARE_IN2_I_P: length 3
  TOP w0.15: 34.34,18.65 v1(33.4,18.65) 32.44,18.65 R83.1
  BOTTOM w0.15: 34.34,18.65 v1(33.4,18.65)
FPGA_SPARE_IN2_N: length 3.3
  TOP w0.15: R97.2 46.57,20.29 v1(45.76,20.29) U19.7
  BOTTOM w0.15: U19.7 v1(45.76,20.29)
FPGA_SPARE_IN2_P: length 3.3
  TOP w0.15: R97.1 46.57,19.02 v1(45.76,19.02) U19.6
  BOTTOM w0.15: U19.6 v1(45.76,19.02)
FPGA_SPARE_OUT1_N: length 3.2
  TOP w0.15: U22.3 29.37,24.98 R100.1 30.34,25.21 v1(30.8,24.75)
FPGA_SPARE_OUT1_P: length 3.2
  TOP w0.15: U22.2 29.37,23.71 R100.2 30.34,23.48 v1(30.8,23.95)
FPGA_SPARE_OUT2_N: length 3.2
  TOP w0.15: U23.2 29.37,13.32 R101.2 30.34,13.09 v1(30.8,13.55)
FPGA_SPARE_OUT2_P: length 3.2
  TOP w0.15: U23.3 29.37,14.59 R101.1 30.34,14.82 v1(30.8,14.35)
HSWAP_LED: length 2.2
  TOP w0.15: U32.11 134.46,107.94 134.47,107.95 R146.1
I2C_SCL: length 16.3
  TOP w0.15: U35.2 v1(151.06,106.02) 152,106.02 R150.1 ; v1(145.6,114.58) U34.6 140.03,114.58 138.2,112.75 137.3,112.75 TP8.1 134.91,111.45 134.6,111.75 U32.14
I2C_SDA: length 17.1
  TOP w0.15: 132.93,113.03 134.97,113.03 TP7.1 136.8,113.25 138,113.25 139.97,115.22 U34.5 v1(146.28,115.22) ; R149.1 151.94,104.75 v1(151,104.75) U35.1
LED_LA_1: length 1.5
  TOP w0.15: U59.5 v1(89.2,132.45)
LED_LA_2: length 2.7
  TOP w0.15: U59.6 v1(88.1,131.19)
LED_LB_1: length 1.5
  TOP w0.15: U59.9 v1(89.22,127.38)
LED_LB_2: length 2.6
  TOP w0.15: 90.75,126.11 v1(88.14,126.11)
LED_LC_1: length 2.8
  TOP w0.15: U59.13 v1(97.22,123.56)
LED_LC_2: length 1.7
  TOP w0.15: U59.14 v1(98.31,124.83)
LED_LD_1: length 2.8
  TOP w0.15: U59.17 v1(97.2,128.64)
LED_LD_2: length 1.7
  TOP w0.15: U59.18 v1(98.33,129.92)
LED_LE_1: length 2.8
  TOP w0.15: 100.05,29.87 v1(97.22,29.87)
LED_LE_2: length 1.7
  TOP w0.15: U60.14 v1(98.31,31.13)
LED_LE_A: length 1.6
  TOP w0.15: U59.4 v1(92.38,133.72)
LED_LE_B: length 1.6
  TOP w0.15: U60.4 v1(92.38,40.02)
LED_LF_1: length 2.8
  TOP w0.15: U60.17 v1(97.2,34.95)
LED_LF_2: length 1.7
  TOP w0.15: U60.18 v1(98.33,36.22)
LED_LG_1: length 1.5
  TOP w0.15: U60.5 v1(89.2,38.76)
LED_LG_2: length 2
  TOP w0.15: U60.6 v1(88.8,37.48)
LED_LH_1: length 1.5
  TOP w0.15: 90.75,33.67 v1(89.22,33.67)
LED_LH_2: length 2.6
  TOP w0.15: 90.75,32.41 v1(88.14,32.41)
LED_SCL: length 5
  TOP w0.15: U59.3 v1(93.25,135) ; U60.3 v1(93.25,41.3)
LED_SDI_A: length 3.7
  TOP w0.15: U59.2 88.21,136.26 88.19,136.25 TP20.1
LED_SDI_B: length 3.7
  TOP w0.15: 90.75,42.56 88.21,42.56 88.19,42.55 TP23.1 87.1,42.55
LED_UA_1: length 1.5
  TOP w0.15: U59.7 v1(89.23,129.92)
LED_UA_2: length 2.6
  TOP w0.15: U59.8 v1(88.11,128.64)
LED_UB_1: length 1.5
  TOP w0.15: U59.11 v1(89.22,124.83)
LED_UB_2: length 2.6
  TOP w0.15: U59.12 v1(88.11,123.56)
LED_UC_1: length 2.8
  TOP w0.15: 100.05,126.11 v1(97.25,126.11)
LED_UC_2: length 1.7
  TOP w0.15: U59.16 v1(98.33,127.38)
LED_UD_1: length 2.8
  TOP w0.15: U59.19 v1(97.23,131.19)
LED_UD_2: length 1.7
  TOP w0.15: U59.20 v1(98.31,132.45)
LED_UE_1: length 2.8
  TOP w0.15: 100.05,32.41 v1(97.25,32.41)
LED_UE_2: length 1.7
  TOP w0.15: 100.05,33.67 v1(98.33,33.67)
LED_UF_1: length 2.8
  TOP w0.15: U60.19 v1(97.23,37.48)
LED_UF_2: length 1.7
  TOP w0.15: U60.20 v1(98.31,38.76)
LED_UG_1: length 1.5
  TOP w0.15: U60.7 v1(89.23,36.22)
LED_UG_2: length 2
  TOP w0.15: U60.8 v1(88.8,34.95)
LED_UH_1: length 1.5
  TOP w0.15: U60.11 v1(89.22,31.13)
LED_UH_2: length 2.6
  TOP w0.15: 90.75,29.87 v1(88.11,29.87)
NO_4_5_MHZ: length 1.1
  TOP w0.15: 123.1,77.62 v1(123.1,78.75)
NO_9_MHZ: length 1.2
  TOP w0.15: U14.12 121.84,78.69 v1(121.9,78.75)
PGOOD: length 3.1
  TOP w0.15: U1.4 v1(131.81,15.14) ; 121.06,110.55 v1(122.1,110.55) 123.21,110.55 U32.4
RESET: length 2.3
  TOP w0.15: U32.6 123.08,107.75 v1(122.1,107.75) 121.06,107.75
RUN_SS_DC: length 7.5
  TOP w0.15: U31.4 143.37,14.51 143.33,14.55 R135.1 ; R136.2 R135.1 ; R135.1 142.66,15.25 143.01,15.59 U33.F23
STATUS_LA_N: length 3
  TOP w0.15: C22.1 v1(53.7,136.85) 52.74,136.85 R20.2
  BOTTOM w0.15: C22.1 v1(53.7,136.85)
STATUS_LA_P: length 3
  TOP w0.15: C23.1 v1(53.7,134.85) 52.74,134.85 R20.1
  BOTTOM w0.15: C23.1 v1(53.7,134.85)
STATUS_LB_N: length 3
  TOP w0.15: R114.2 52.74,126.15 v1(53.7,126.15) C73.1
  BOTTOM w0.15: C73.1 v1(53.7,126.15)
STATUS_LB_P: length 3
  TOP w0.15: R114.1 52.74,124.15 v1(53.7,124.15) C74.1
  BOTTOM w0.15: C74.1 v1(53.7,124.15)
STATUS_LC_N: length 3
  TOP w0.15: C59.1 v1(53.7,115.45) 52.74,115.45 R104.2
  BOTTOM w0.15: C59.1 v1(53.7,115.45)
STATUS_LC_P: length 3
  TOP w0.15: C60.1 v1(53.7,113.45) 52.74,113.45 R104.1
  BOTTOM w0.15: C60.1 v1(53.7,113.45)
STATUS_LD_N: length 3
  TOP w0.15: C71.1 v1(53.7,104.75) 52.74,104.75 R113.2
  BOTTOM w0.15: C71.1 v1(53.7,104.75)
STATUS_LD_P: length 3
  TOP w0.15: C72.1 v1(53.7,102.75) 52.74,102.75 R113.1
  BOTTOM w0.15: C72.1 v1(53.7,102.75)
STATUS_LE_N: length 3
  TOP w0.15: C104.1 v1(53.7,64.65) 52.74,64.65 R162.2
  BOTTOM w0.15: C104.1 v1(53.7,64.65)
STATUS_LE_P: length 3
  TOP w0.15: R162.1 52.74,62.65 v1(53.7,62.65) C105.1
  BOTTOM w0.15: C105.1 v1(53.7,62.65)
STATUS_LF_N: length 3
  TOP w0.15: C118.1 v1(53.7,53.95) 52.74,53.95 R180.2
  BOTTOM w0.15: C118.1 v1(53.7,53.95)
STATUS_LF_P: length 3
  TOP w0.15: C119.1 v1(53.7,51.95) 52.74,51.95 52.6,52.09
  BOTTOM w0.15: C119.1 v1(53.7,51.95)
STATUS_LG_N: length 3
  TOP w0.15: C102.1 v1(53.7,43.25) 52.74,43.25 R161.2
  BOTTOM w0.15: C102.1 v1(53.7,43.25)
STATUS_LG_P: length 3
  TOP w0.15: R161.1 52.74,41.25 v1(53.7,41.25) C103.1
  BOTTOM w0.15: C103.1 v1(53.7,41.25)
STATUS_LH_N: length 3
  TOP w0.15: R179.2 52.74,32.55 v1(53.7,32.55) C116.1
  BOTTOM w0.15: C116.1 v1(53.7,32.55)
STATUS_LH_P: length 3
  TOP w0.15: R179.1 52.74,30.55 v1(53.7,30.55) C117.1
  BOTTOM w0.15: C117.1 v1(53.7,30.55)
STATUS_OUT_LA_N: length 3.3
  TOP w0.15: R37.2 66.87,136.49 v1(66.06,136.49) U7.7
  BOTTOM w0.15: U7.7 v1(66.06,136.49)
STATUS_OUT_LA_P: length 3.3
  TOP w0.15: U7.6 v1(66.06,135.22) 66.87,135.22 R37.1
  BOTTOM w0.15: U7.6 v1(66.06,135.22)
STATUS_OUT_LB_N: length 3.3
  TOP w0.15: R128.2 66.87,125.78 v1(66.06,125.78) U27.7
  BOTTOM w0.15: U27.7 v1(66.06,125.78)
STATUS_OUT_LB_P: length 3.3
  TOP w0.15: R128.1 66.87,124.52 v1(66.06,124.52) U27.6
  BOTTOM w0.15: U27.6 v1(66.06,124.52)
STATUS_OUT_LC_N: length 3.3
  TOP w0.15: U24.7 v1(66.06,115.08) 66.87,115.08 R111.2
  BOTTOM w0.15: U24.7 v1(66.06,115.08)
STATUS_OUT_LC_P: length 3.3
  TOP w0.15: R111.1 66.87,113.81 v1(66.06,113.81) U24.6
  BOTTOM w0.15: U24.6 v1(66.06,113.81)
STATUS_OUT_LD_N: length 3.3
  TOP w0.15: U26.7 v1(66.06,104.39) 66.87,104.39 R127.2
  BOTTOM w0.15: U26.7 v1(66.06,104.39)
STATUS_OUT_LD_P: length 3.3
  TOP w0.15: U26.6 v1(66.06,103.11) 66.87,103.11 R127.1
  BOTTOM w0.15: U26.6 v1(66.06,103.11)
STATUS_OUT_LE_N: length 3.3
  TOP w0.15: R176.2 66.87,64.28 v1(66.06,64.28) U37.7
  BOTTOM w0.15: U37.7 v1(66.06,64.28)
STATUS_OUT_LE_P: length 3.3
  TOP w0.15: R176.1 66.87,63.02 v1(66.06,63.02) U37.6
  BOTTOM w0.15: U37.6 v1(66.06,63.02)
STATUS_OUT_LF_N: length 3.3
  TOP w0.15: R194.2 66.87,53.59 v1(66.06,53.59) U41.7
  BOTTOM w0.15: U41.7 v1(66.06,53.59)
STATUS_OUT_LF_P: length 3.3
  TOP w0.15: 67.1,52.09 66.87,52.31 v1(66.06,52.31) U41.6
  BOTTOM w0.15: U41.6 v1(66.06,52.31)
STATUS_OUT_LG_N: length 3.3
  TOP w0.15: R175.2 66.87,42.88 v1(66.06,42.88) U36.7
  BOTTOM w0.15: U36.7 v1(66.06,42.88)
STATUS_OUT_LG_P: length 3.3
  TOP w0.15: R175.1 66.87,41.62 v1(66.06,41.62) U36.6
  BOTTOM w0.15: U36.6 v1(66.06,41.62)
STATUS_OUT_LH_N: length 3.3
  TOP w0.15: U40.7 v1(66.06,32.19) 66.87,32.19 R193.2
  BOTTOM w0.15: U40.7 v1(66.06,32.19)
STATUS_OUT_LH_P: length 3.3
  TOP w0.15: R193.1 66.87,30.91 v1(66.06,30.91) U40.6
  BOTTOM w0.15: U40.6 v1(66.06,30.91)
STATUS_OUT_UA_N: length 3.3
  TOP w0.15: U2.7 v1(83.67,131.19) 84.47,131.19 R248.2
  BOTTOM w0.15: U2.7 v1(83.67,131.19)
STATUS_OUT_UA_P: length 3.3
  TOP w0.15: R248.1 84.47,129.92 v1(83.67,129.92) U2.6
  BOTTOM w0.15: U2.6 v1(83.67,129.92)
STATUS_OUT_UB_N: length 3.3
  TOP w0.15: U56.7 v1(83.67,120.48) 84.47,120.48 R266.2
  BOTTOM w0.15: U56.7 v1(83.67,120.48)
STATUS_OUT_UB_P: length 3.3
  TOP w0.15: U56.6 v1(83.67,119.22) 84.47,119.22 R266.1
  BOTTOM w0.15: U56.6 v1(83.67,119.22)
STATUS_OUT_UC_N: length 3.3
  TOP w0.15: R247.2 84.47,109.78 v1(83.67,109.78) U52.7
  BOTTOM w0.15: U52.7 v1(83.67,109.78)
STATUS_OUT_UC_P: length 3.3
  TOP w0.15: U52.6 v1(83.67,108.52) 84.47,108.52 R247.1
  BOTTOM w0.15: U52.6 v1(83.67,108.52)
STATUS_OUT_UD_N: length 3.3
  TOP w0.15: U55.7 v1(83.67,99.09) 84.47,99.09 84.7,99.31
  BOTTOM w0.15: U55.7 v1(83.67,99.09)
STATUS_OUT_UD_P: length 3.3
  TOP w0.15: 82.57,97.81 v1(83.67,97.81) 84.47,97.81 R265.1
  BOTTOM w0.15: 82.57,97.81 v1(83.67,97.81)
STATUS_OUT_UE_N: length 3.3
  TOP w0.15: U45.7 v1(83.67,69.59) 84.47,69.59 84.7,69.81
  BOTTOM w0.15: U45.7 v1(83.67,69.59)
STATUS_OUT_UE_P: length 3.3
  TOP w0.15: R212.1 84.47,68.31 v1(83.67,68.31) U45.6
  BOTTOM w0.15: U45.6 v1(83.67,68.31)
STATUS_OUT_UF_N: length 3.3
  TOP w0.15: U49.7 v1(83.67,58.89) 84.47,58.89 R230.2
  BOTTOM w0.15: U49.7 v1(83.67,58.89)
STATUS_OUT_UF_P: length 3.3
  TOP w0.15: U49.6 v1(83.67,57.61) 84.47,57.61 R230.1
  BOTTOM w0.15: U49.6 v1(83.67,57.61)
STATUS_OUT_UG_N: length 3.3
  TOP w0.15: U44.7 v1(83.67,48.19) 84.47,48.19 84.7,48.41
  BOTTOM w0.15: U44.7 v1(83.67,48.19)
STATUS_OUT_UG_P: length 3.3
  TOP w0.15: 82.57,46.91 v1(83.67,46.91) 84.47,46.91 R211.1
  BOTTOM w0.15: 82.57,46.91 v1(83.67,46.91)
STATUS_OUT_UH_N: length 3.3
  TOP w0.15: R229.2 84.47,37.48 v1(83.67,37.48) U48.7
  BOTTOM w0.15: U48.7 v1(83.67,37.48)
STATUS_OUT_UH_P: length 3.3
  TOP w0.15: U48.6 v1(83.67,36.22) 84.47,36.22 R229.1
  BOTTOM w0.15: U48.6 v1(83.67,36.22)
STATUS_UA_N: length 3
  TOP w0.15: R234.2 70.33,131.55 v1(71.3,131.55) C160.1
  BOTTOM w0.15: C160.1 v1(71.3,131.55)
STATUS_UA_P: length 3
  TOP w0.15: R234.1 70.33,129.55 v1(71.3,129.55) C161.1
  BOTTOM w0.15: C161.1 v1(71.3,129.55)
STATUS_UB_N: length 3
  TOP w0.15: R252.2 70.33,120.85 v1(71.3,120.85) C174.1
  BOTTOM w0.15: C174.1 v1(71.3,120.85)
STATUS_UB_P: length 3
  TOP w0.15: C175.1 v1(71.3,118.85) 70.33,118.85 R252.1
  BOTTOM w0.15: C175.1 v1(71.3,118.85)
STATUS_UC_N: length 3
  TOP w0.15: R233.2 70.33,110.15 v1(71.3,110.15) C158.1
  BOTTOM w0.15: C158.1 v1(71.3,110.15)
STATUS_UC_P: length 3
  TOP w0.15: R233.1 70.33,108.15 v1(71.3,108.15) C159.1
  BOTTOM w0.15: C159.1 v1(71.3,108.15)
STATUS_UD_N: length 3
  TOP w0.15: 70.2,99.31 70.33,99.45 v1(71.3,99.45) C172.1
  BOTTOM w0.15: C172.1 v1(71.3,99.45)
STATUS_UD_P: length 3
  TOP w0.15: R251.1 70.33,97.45 v1(71.3,97.45) C173.1
  BOTTOM w0.15: C173.1 v1(71.3,97.45)
STATUS_UE_N: length 3
  TOP w0.15: C132.1 v1(71.3,69.95) 70.33,69.95 70.2,69.81
  BOTTOM w0.15: C132.1 v1(71.3,69.95)
STATUS_UE_P: length 3
  TOP w0.15: C133.1 v1(71.3,67.95) 70.33,67.95 R198.1
  BOTTOM w0.15: C133.1 v1(71.3,67.95)
STATUS_UF_N: length 3
  TOP w0.15: R216.2 70.33,59.25 v1(71.3,59.25) C146.1
  BOTTOM w0.15: C146.1 v1(71.3,59.25)
STATUS_UF_P: length 3
  TOP w0.15: R216.1 70.33,57.25 v1(71.3,57.25) C147.1
  BOTTOM w0.15: C147.1 v1(71.3,57.25)
STATUS_UG_N: length 3
  TOP w0.15: 70.2,48.41 70.33,48.55 v1(71.3,48.55) C130.1
  BOTTOM w0.15: C130.1 v1(71.3,48.55)
STATUS_UG_P: length 3
  TOP w0.15: C131.1 v1(71.3,46.55) 70.33,46.55 R197.1
  BOTTOM w0.15: C131.1 v1(71.3,46.55)
STATUS_UH_N: length 3
  TOP w0.15: C144.1 v1(71.3,37.85) 70.33,37.85 R215.2
  BOTTOM w0.15: C144.1 v1(71.3,37.85)
STATUS_UH_P: length 3
  TOP w0.15: R215.1 70.33,35.85 v1(71.3,35.85) C145.1
  BOTTOM w0.15: C145.1 v1(71.3,35.85)
SW_HOT_SWAP: length 5.8
  TOP w0.15: v1(30.48,141.17) SW2.C SW2.A ; 121.06,106.35 121.9,106.35 v1(122.1,106.55) 123.15,106.55 U32.7
  BOTTOM w0.15: DS5.2 v1(12.2,144.65)
UNNAMED_1_CAPACITOR_I90_B: length 6.5
  TOP w0.15: U18.2 37.83,8.79 R85.2 37.47,9.15 C36.2 35.94,9.28 v1(35.94,10.15) R84.1
  BOTTOM w0.15: R84.1 v1(35.94,10.15)
UNNAMED_1_CAPACITOR_I99_B: length 6.5
  TOP w0.15: U18.3 37.83,7.52 R85.1 37.47,7.15 C37.2 35.94,7.02 v1(35.94,6.15) R86.2
  BOTTOM w0.15: R86.2 v1(35.94,6.15)
UNNAMED_1_CAPACITOR_I100_B: length 6.5
  TOP w0.15: U19.2 37.83,20.29 R88.2 37.47,20.65 C38.2 35.94,20.78 v1(35.94,21.65) R87.1
  BOTTOM w0.15: R87.1 v1(35.94,21.65)
UNNAMED_1_CAPACITOR_I101_B: length 6.5
  TOP w0.15: U19.3 37.83,19.02 R88.1 37.47,18.65 C39.2 35.94,18.52 v1(35.94,17.65) R89.2
  BOTTOM w0.15: R89.2 v1(35.94,17.65)
UNNAMED_1_DS90LV001_I70_EN: length 1.7
  TOP w0.15: R102.1 22.53,21.45 22.53,21.45 U22.8
UNNAMED_1_DS90LV001_I71_EN: length 1.7
  TOP w0.15: R103.1 22.53,11.05 22.53,11.05 22.53,12.05
UNNAMED_1_DS90LV001_I78_EN: length 1.8
  TOP w0.15: 44.76,11.85 44.76,11.15 44.67,11.05 U18.8
UNNAMED_1_DS90LV001_I79_EN: length 1.8
  TOP w0.15: 39.24,11.85 v1(39.24,10.89)
  BOTTOM w0.15: U20.8 39.24,10.15 v1(39.24,10.89)
UNNAMED_1_DS90LV001_I79_OUT: length 3.2
  TOP w0.15: 37.66,5.15 38,5.48 v1(38,6.15)
  BOTTOM w0.15: v1(38,6.15) 38.38,6.53 38.38,6.88 39.02,7.52 U20.6
UNNAMED_1_DS90LV001_I79_OUT_1: length 3.2
  TOP w0.15: 37.66,11.15 38,10.82 v1(38,10.15)
  BOTTOM w0.15: v1(38,10.15) 38.38,9.77 38.38,9.42 39.02,8.79 U20.7
UNNAMED_1_DS90LV001_I80_EN: length 1.8
  TOP w0.15: 39.24,23.35 v1(39.24,22.38)
  BOTTOM w0.15: U21.8 39.24,21.65 v1(39.24,22.38)
UNNAMED_1_DS90LV001_I80_OUT: length 3.2
  TOP w0.15: 37.66,16.65 38,16.98 v1(38,17.65)
  BOTTOM w0.15: v1(38,17.65) 38.38,18.03 38.38,18.38 39.02,19.02 U21.6
UNNAMED_1_DS90LV001_I80_OUT_1: length 3.2
  TOP w0.15: 37.66,22.65 38,22.31 v1(38,21.65)
  BOTTOM w0.15: U21.7 39.02,20.29 38.38,20.92 38.38,21.27 v1(38,21.65)
UNNAMED_1_DS90LV001_I81_EN: length 1.8
  TOP w0.15: U19.8 44.67,22.55 44.76,22.65 44.76,23.35
UNNAMED_2_CAPACITOR_I8_B: length 6.5
  TOP w0.15: R24.1 v1(56.23,137.85) 56.23,136.98 C22.2 57.77,136.85 R25.2 58.13,136.49 U7.2
  BOTTOM w0.15: R24.1 v1(56.23,137.85)
UNNAMED_2_CAPACITOR_I25_B: length 6.5
  TOP w0.15: U7.3 58.13,135.22 R25.1 57.77,134.85 C23.2 56.23,134.72 v1(56.23,133.85) R26.2
  BOTTOM w0.15: R26.2 v1(56.23,133.85)
UNNAMED_2_CAPACITOR_I157_B: length 6.5
  TOP w0.15: U27.2 58.13,125.78 R119.2 57.77,126.15 C73.2 56.23,126.28 v1(56.23,127.15) R118.1
  BOTTOM w0.15: R118.1 v1(56.23,127.15)
UNNAMED_2_CAPACITOR_I170_B: length 6.5
  TOP w0.15: U27.3 58.13,124.52 R119.1 57.77,124.15 C74.2 56.23,124.02 v1(56.23,123.15) R120.2
  BOTTOM w0.15: R120.2 v1(56.23,123.15)
UNNAMED_2_CAPACITOR_I189_B: length 6.5
  TOP w0.15: U24.2 58.13,115.08 R106.2 57.77,115.45 C59.2 56.23,115.58 v1(56.23,116.45) R105.1
  BOTTOM w0.15: R105.1 v1(56.23,116.45)
UNNAMED_2_CAPACITOR_I190_B: length 6.5
  TOP w0.15: R107.2 v1(56.23,112.45) 56.23,113.32 C60.2 57.77,113.45 R106.1 58.13,113.81 U24.3
  BOTTOM w0.15: R107.2 v1(56.23,112.45)
UNNAMED_2_CAPACITOR_I209_B: length 6.5
  TOP w0.15: U26.2 58.13,104.39 R116.2 57.77,104.75 C71.2 56.23,104.88 v1(56.23,105.75) R115.1
  BOTTOM w0.15: R115.1 v1(56.23,105.75)
UNNAMED_2_CAPACITOR_I210_B: length 6.5
  TOP w0.15: U26.3 58.13,103.11 R116.1 57.77,102.75 C72.2 56.23,102.62 v1(56.23,101.75) R117.2
  BOTTOM w0.15: R117.2 v1(56.23,101.75)
UNNAMED_2_DS90LV001_I18_EN: length 1.8
  TOP w0.15: U7.8 64.97,138.75 65.06,138.85 R35.1
UNNAMED_2_DS90LV001_I19_EN: length 1.8
  TOP w0.15: R39.1 v1(59.53,138.58)
  BOTTOM w0.15: v1(59.53,138.58) 59.53,137.85 U9.8
UNNAMED_2_DS90LV001_I19_OUT: length 3.2
  TOP w0.15: v1(58.3,137.85) 58.3,138.51 R24.2
  BOTTOM w0.15: U9.7 59.32,136.49 58.68,137.12 58.68,137.47 v1(58.3,137.85)
UNNAMED_2_DS90LV001_I19_OUT_1: length 3.2
  TOP w0.15: v1(58.3,133.85) 58.3,133.19 R26.1
  BOTTOM w0.15: v1(58.3,133.85) 58.68,134.23 58.68,134.58 59.32,135.22 U9.6
UNNAMED_2_DS90LV001_I162_EN: length 1.8
  TOP w0.15: R130.1 v1(59.53,127.89)
  BOTTOM w0.15: U29.8 59.53,127.15 v1(59.53,127.89)
UNNAMED_2_DS90LV001_I162_OUT: length 3.2
  TOP w0.15: v1(58.3,127.15) 58.3,127.81 R118.2
  BOTTOM w0.15: v1(58.3,127.15) 58.68,126.77 58.68,126.42 59.32,125.78 U29.7
UNNAMED_2_DS90LV001_I162_OUT_1: length 3.2
  TOP w0.15: v1(58.3,123.15) 58.3,122.48 R120.1
  BOTTOM w0.15: v1(58.3,123.15) 58.68,123.53 58.68,123.88 59.32,124.52 U29.6
UNNAMED_2_DS90LV001_I166_EN: length 1.8
  TOP w0.15: R126.1 65.06,128.15 64.97,128.05 U27.8
UNNAMED_2_DS90LV001_I181_EN: length 1.8
  TOP w0.15: R112.1 v1(59.53,117.19)
  BOTTOM w0.15: U25.8 59.53,116.45 v1(59.53,117.19)
UNNAMED_2_DS90LV001_I181_OUT: length 3.2
  TOP w0.15: v1(58.3,112.45) 58.3,111.78 R107.1
  BOTTOM w0.15: U25.6 59.32,113.81 58.68,113.18 58.68,112.83 v1(58.3,112.45)
UNNAMED_2_DS90LV001_I181_OUT_1: length 3.2
  TOP w0.15: v1(58.3,116.45) 58.3,117.11 R105.2
  BOTTOM w0.15: U25.7 59.32,115.08 58.68,115.72 58.68,116.07 v1(58.3,116.45)
UNNAMED_2_DS90LV001_I185_EN: length 1.8
  TOP w0.15: U24.8 64.97,117.35 65.06,117.45 R110.1
UNNAMED_2_DS90LV001_I201_EN: length 1.8
  TOP w0.15: R129.1 v1(59.53,106.48)
  BOTTOM w0.15: U28.8 59.53,105.75 v1(59.53,106.48)
UNNAMED_2_DS90LV001_I201_OUT: length 3.2
  TOP w0.15: R115.2 58.3,106.42 v1(58.3,105.75)
  BOTTOM w0.15: U28.7 59.32,104.39 58.68,105.02 58.68,105.37 v1(58.3,105.75)
UNNAMED_2_DS90LV001_I201_OUT_1: length 3.2
  TOP w0.15: R117.1 58.3,101.08 v1(58.3,101.75)
  BOTTOM w0.15: U28.6 59.32,103.11 58.68,102.48 58.68,102.13 v1(58.3,101.75)
UNNAMED_2_DS90LV001_I205_EN: length 1.8
  TOP w0.15: R125.1 65.06,106.75 64.97,106.65 U26.8
UNNAMED_4_CAPACITOR_I14_B: length 6.5
  TOP w0.15: U52.3 75.73,108.52 R236.1 75.36,108.15 C159.2 73.83,108.02 v1(73.83,107.15) R237.2
  BOTTOM w0.15: R237.2 v1(73.83,107.15)
UNNAMED_4_CAPACITOR_I15_B: length 6.5
  TOP w0.15: U52.2 75.73,109.78 R236.2 75.36,110.15 C158.2 73.83,110.28 v1(73.83,111.15) R235.1
  BOTTOM w0.15: R235.1 v1(73.83,111.15)
UNNAMED_4_CAPACITOR_I30_B: length 6.5
  TOP w0.15: R242.2 v1(73.83,128.55) 73.83,129.42 C161.2 75.36,129.55 R241.1 75.73,129.92 U2.3
  BOTTOM w0.15: R242.2 v1(73.83,128.55)
UNNAMED_4_CAPACITOR_I31_B: length 6.5
  TOP w0.15: R240.1 v1(73.83,132.55) 73.83,131.68 C160.2 75.36,131.55 R241.2 75.73,131.19 U2.2
  BOTTOM w0.15: R240.1 v1(73.83,132.55)
UNNAMED_4_CAPACITOR_I61_B: length 6.5
  TOP w0.15: 77.23,97.81 75.73,97.81 R254.1 75.36,97.45 C173.2 73.83,97.32 v1(73.83,96.45) R255.2
  BOTTOM w0.15: R255.2 v1(73.83,96.45)
UNNAMED_4_CAPACITOR_I62_B: length 6.5
  TOP w0.15: R253.1 v1(73.83,100.45) 73.83,99.58 C172.2 75.36,99.45 75.73,99.09 U55.2
  BOTTOM w0.15: R253.1 v1(73.83,100.45)
UNNAMED_4_CAPACITOR_I79_B: length 6.5
  TOP w0.15: U56.3 75.73,119.22 R257.1 75.36,118.85 C175.2 73.83,118.72 v1(73.83,117.85) R258.2
  BOTTOM w0.15: R258.2 v1(73.83,117.85)
UNNAMED_4_CAPACITOR_I80_B: length 6.5
  TOP w0.15: R256.1 v1(73.83,121.85) 73.83,120.98 C174.2 75.36,120.85 R257.2 75.73,120.48 U56.2
  BOTTOM w0.15: R256.1 v1(73.83,121.85)
UNNAMED_4_DS90LV001_I18_EN: length 1.8
  TOP w0.15: U52.8 82.57,112.05 82.67,112.15 R245.1
UNNAMED_4_DS90LV001_I38_EN: length 1.8
  TOP w0.15: R249.1 v1(77.14,111.89)
  BOTTOM w0.15: U53.8 77.14,111.15 v1(77.14,111.89)
UNNAMED_4_DS90LV001_I38_OUT: length 3.2
  TOP w0.15: R235.2 75.9,111.81 v1(75.9,111.15)
  BOTTOM w0.15: U53.7 76.92,109.78 76.28,110.42 76.28,110.77 v1(75.9,111.15)
UNNAMED_4_DS90LV001_I38_OUT_1: length 3.2
  TOP w0.15: v1(75.9,107.15) 75.9,106.48 R237.1
  BOTTOM w0.15: U53.6 76.92,108.52 76.28,107.88 76.28,107.53 v1(75.9,107.15)
UNNAMED_4_DS90LV001_I39_EN: length 1.8
  TOP w0.15: U2.8 82.57,133.45 82.67,133.55 R246.1
UNNAMED_4_DS90LV001_I43_EN: length 1.8
  TOP w0.15: R250.1 v1(77.14,133.28)
  BOTTOM w0.15: U54.8 77.14,132.55 v1(77.14,133.28)
UNNAMED_4_DS90LV001_I43_OUT: length 3.2
  TOP w0.15: v1(75.9,128.55) 75.9,127.89 R242.1
  BOTTOM w0.15: U54.6 76.92,129.92 76.28,129.28 76.28,128.93 v1(75.9,128.55)
UNNAMED_4_DS90LV001_I43_OUT_1: length 3.2
  TOP w0.15: R240.2 75.9,133.22 v1(75.9,132.55)
  BOTTOM w0.15: v1(75.9,132.55) 76.28,132.17 76.28,131.82 76.92,131.19 U54.7
UNNAMED_4_DS90LV001_I68_EN: length 1.8
  TOP w0.15: R263.1 82.67,101.45 82.57,101.35 82.57,100.35
UNNAMED_4_DS90LV001_I85_EN: length 1.8
  TOP w0.15: R264.1 82.67,122.85 82.57,122.75 U56.8
UNNAMED_4_DS90LV001_I90_EN: length 1.8
  TOP w0.15: R267.1 v1(77.14,101.19)
  BOTTOM w0.15: v1(77.14,101.19) 77.14,100.45 77.23,100.35
UNNAMED_4_DS90LV001_I90_OUT: length 3.2
  TOP w0.15: v1(75.9,100.45) 75.9,101.11 R253.2
  BOTTOM w0.15: v1(75.9,100.45) 76.28,100.07 76.28,99.72 76.92,99.09 U57.7
UNNAMED_4_DS90LV001_I90_OUT_1: length 3.2
  TOP w0.15: v1(75.9,96.45) 75.9,95.78 R255.1
  BOTTOM w0.15: v1(75.9,96.45) 76.28,96.83 76.28,97.18 76.92,97.81 77.23,97.81
UNNAMED_4_DS90LV001_I94_EN: length 1.8
  TOP w0.15: R268.1 v1(77.14,122.58)
  BOTTOM w0.15: v1(77.14,122.58) 77.14,121.85 U58.8
UNNAMED_4_DS90LV001_I94_OUT: length 3.2
  TOP w0.15: v1(75.9,121.85) 75.9,122.52 R256.2
  BOTTOM w0.15: U58.7 76.92,120.48 76.28,121.12 76.28,121.47 v1(75.9,121.85)
UNNAMED_4_DS90LV001_I94_OUT_1: length 3.2
  TOP w0.15: R258.1 75.9,117.19 v1(75.9,117.85)
  BOTTOM w0.15: v1(75.9,117.85) 76.28,118.23 76.28,118.58 76.92,119.22 U58.6
UNNAMED_5_CAPACITOR_I14_B: length 6.5
  TOP w0.15: R201.2 v1(73.83,45.55) 73.83,46.42 C131.2 75.36,46.55 R200.1 75.73,46.91 77.23,46.91
  BOTTOM w0.15: R201.2 v1(73.83,45.55)
UNNAMED_5_CAPACITOR_I15_B: length 6.5
  TOP w0.15: R199.1 v1(73.83,49.55) 73.83,48.68 C130.2 75.36,48.55 75.73,48.19 U44.2
  BOTTOM w0.15: R199.1 v1(73.83,49.55)
UNNAMED_5_CAPACITOR_I30_B: length 6.5
  TOP w0.15: U45.3 75.73,68.31 R205.1 75.36,67.95 C133.2 73.83,67.82 v1(73.83,66.95) R206.2
  BOTTOM w0.15: R206.2 v1(73.83,66.95)
UNNAMED_5_CAPACITOR_I31_B: length 6.5
  TOP w0.15: U45.2 75.73,69.59 75.36,69.95 C132.2 73.83,70.08 v1(73.83,70.95) R204.1
  BOTTOM w0.15: R204.1 v1(73.83,70.95)
UNNAMED_5_CAPACITOR_I61_B: length 6.5
  TOP w0.15: U48.3 75.73,36.22 R218.1 75.36,35.85 C145.2 73.83,35.72 v1(73.83,34.85) R219.2
  BOTTOM w0.15: R219.2 v1(73.83,34.85)
UNNAMED_5_CAPACITOR_I62_B: length 6.5
  TOP w0.15: R217.1 v1(73.83,38.85) 73.83,37.98 C144.2 75.36,37.85 R218.2 75.73,37.48 U48.2
  BOTTOM w0.15: R217.1 v1(73.83,38.85)
UNNAMED_5_CAPACITOR_I79_B: length 6.5
  TOP w0.15: R222.2 v1(73.83,56.25) 73.83,57.12 C147.2 75.36,57.25 R221.1 75.73,57.61 U49.3
  BOTTOM w0.15: R222.2 v1(73.83,56.25)
UNNAMED_5_CAPACITOR_I80_B: length 6.5
  TOP w0.15: R220.1 v1(73.83,60.25) 73.83,59.38 C146.2 75.36,59.25 R221.2 75.73,58.89 U49.2
  BOTTOM w0.15: R220.1 v1(73.83,60.25)
UNNAMED_5_DS90LV001_I18_EN: length 1.8
  TOP w0.15: U44.8 82.57,50.45 82.67,50.55 R209.1
UNNAMED_5_DS90LV001_I38_EN: length 1.8
  TOP w0.15: R213.1 v1(77.14,50.28)
  BOTTOM w0.15: U46.8 77.14,49.55 v1(77.14,50.28)
UNNAMED_5_DS90LV001_I38_OUT: length 3.2
  TOP w0.15: v1(75.9,45.55) 75.9,44.88 R201.1
  BOTTOM w0.15: 77.23,46.91 76.92,46.91 76.28,46.28 76.28,45.93 v1(75.9,45.55)
UNNAMED_5_DS90LV001_I38_OUT_1: length 3.2
  TOP w0.15: v1(75.9,49.55) 75.9,50.22 R199.2
  BOTTOM w0.15: v1(75.9,49.55) 76.28,49.17 76.28,48.82 76.92,48.19 U46.7
UNNAMED_5_DS90LV001_I39_EN: length 1.8
  TOP w0.15: 82.57,70.85 82.57,71.85 82.67,71.95 R210.1
UNNAMED_5_DS90LV001_I43_EN: length 1.8
  TOP w0.15: R214.1 v1(77.14,71.69)
  BOTTOM w0.15: 77.23,70.85 77.14,70.95 v1(77.14,71.69)
UNNAMED_5_DS90LV001_I43_OUT: length 3.2
  TOP w0.15: R206.1 75.9,66.28 v1(75.9,66.95)
  BOTTOM w0.15: v1(75.9,66.95) 76.28,67.33 76.28,67.68 76.92,68.31 U47.6
UNNAMED_5_DS90LV001_I43_OUT_1: length 3.2
  TOP w0.15: v1(75.9,70.95) 75.9,71.62 R204.2
  BOTTOM w0.15: v1(75.9,70.95) 76.28,70.57 76.28,70.22 76.92,69.59 U47.7
UNNAMED_5_DS90LV001_I68_EN: length 1.8
  TOP w0.15: R227.1 82.67,39.85 82.57,39.75 U48.8
UNNAMED_5_DS90LV001_I85_EN: length 1.8
  TOP w0.15: R228.1 82.67,61.25 82.57,61.15 U49.8
UNNAMED_5_DS90LV001_I90_EN: length 1.8
  TOP w0.15: R231.1 v1(77.14,39.59)
  BOTTOM w0.15: v1(77.14,39.59) 77.14,38.85 77.23,38.76
UNNAMED_5_DS90LV001_I90_OUT: length 3.2
  TOP w0.15: v1(75.9,34.85) 75.9,34.19 R219.1
  BOTTOM w0.15: v1(75.9,34.85) 76.28,35.23 76.28,35.58 76.92,36.22 77.23,36.22
UNNAMED_5_DS90LV001_I90_OUT_1: length 3.2
  TOP w0.15: v1(75.9,38.85) 75.9,39.52 R217.2
  BOTTOM w0.15: v1(75.9,38.85) 76.28,38.47 76.28,38.12 76.92,37.48 U50.7
UNNAMED_5_DS90LV001_I94_EN: length 1.8
  TOP w0.15: R232.1 v1(77.14,60.98)
  BOTTOM w0.15: v1(77.14,60.98) 77.14,60.25 U51.8
UNNAMED_5_DS90LV001_I94_OUT: length 3.2
  TOP w0.15: R222.1 75.9,55.59 v1(75.9,56.25)
  BOTTOM w0.15: v1(75.9,56.25) 76.28,56.63 76.28,56.98 76.92,57.61 U51.6
UNNAMED_5_DS90LV001_I94_OUT_1: length 3.2
  TOP w0.15: v1(75.9,60.25) 75.9,60.91 R220.2
  BOTTOM w0.15: U51.7 76.92,58.89 76.28,59.52 76.28,59.87 v1(75.9,60.25)
UNNAMED_6_74LVC1G34_I76_Y: length 4.8
  TOP w0.15: U1.2 135.22,13.35 135.69,13.83 135.69,13.89 136.09,14.29 U30.4 v1(136.16,15.09)
  BOTTOM w0.15: R134.1 v1(151.37,98.59)
UNNAMED_6_AT24C32C_I14_A0: length 3.8
  TOP w0.15: U34.1 151.07,113.28 v1(151.4,112.95) 152.03,112.95 R314.1
  BOTTOM w0.15: R314.1 152.03,112.95 v1(151.4,112.95)
UNNAMED_6_AT24C32C_I14_A1: length 3.3
  TOP w0.15: U34.2 v1(151.47,113.92) 152.41,113.92 R316.1
  BOTTOM w0.15: R316.1 152.41,113.92 v1(151.47,113.92)
UNNAMED_6_AT24C32C_I14_A2: length 3.9
  TOP w0.15: U34.3 151.05,114.58 v1(151.4,114.92) 152.01,114.92 R148.1
  BOTTOM w0.15: R148.1 152.01,114.92 v1(151.4,114.92)
UNNAMED_6_CAPACITOR_I59_B: length 5.5
  TOP w0.15: U33.A15 149.46,23.85 149.47,23.85 R137.2 C81.2
UNNAMED_6_CAPACITOR_I62_A: length 5.6
  TOP w0.15: U33.A21 149.45,20.04 149.47,20.05 R144.2 C82.1
UNNAMED_6_LED-SMD_I19_A1: length 2.4
  BOTTOM w0.15: R151.2 13.8,141.88 13.66,141.75 DS5.1
UNNAMED_6_LED-SMD_I21_A1: length 2.1
  BOTTOM w0.15: R152.2 7,2.59 6.83,2.42 DS6.1
UNNAMED_6_LED-SMD_I22_A1: length 2.3
  TOP w0.15: DS1.1 v1(11.53,3.42)
  BOTTOM w0.15: R153.2 12.31,3.42 v1(11.53,3.42)
UNNAMED_6_LED-SMD_I70_A1: length 2.4
  TOP w0.15: DS3.1 v1(149.68,95.83)
  BOTTOM w0.15: v1(149.68,95.83) 149.31,95.46 149.31,95.11 R132.2
UNNAMED_6_LED-SMD_I71_A1: length 2.4
  TOP w0.15: DS2.1 v1(149.68,90.33)
  BOTTOM w0.15: R131.2 149.68,89.4 v1(149.68,90.33)
UNNAMED_6_LED-SMD_I81_A1: length 2.4
  TOP w0.15: DS4.1 v1(149.68,101.33)
  BOTTOM w0.15: v1(149.68,101.33) 149.63,101.28 R134.2
UNNAMED_6_LM75A_I38_A0: length 3.5
  TOP w0.15: R158.1 142.43,106.02 v1(143.34,106.02) U35.7
  BOTTOM w0.15: R158.1 142.43,106.02 v1(143.34,106.02)
UNNAMED_6_LM75A_I38_A1: length 3.4
  TOP w0.15: U35.6 v1(143.34,107.28) 142.3,107.28 R156.1
  BOTTOM w0.15: v1(143.34,107.28) 142.3,107.28 R156.1
UNNAMED_6_LM75A_I38_A2: length 3.4
  TOP w0.15: R154.1 142.36,108.56 v1(143.31,108.56) U35.5
  BOTTOM w0.15: v1(143.31,108.56) 142.36,108.56 R154.1
UNNAMED_6_LM75A_I38_OS: length 2.2
  TOP w0.15: R160.1 151.87,107.28 v1(151.06,107.28) U35.3
UNNAMED_6_PCF8574_I3_A0: length 3.6
  TOP w0.15: 121.06,114.75 121.73,114.75 v1(122.1,114.38) 123.19,114.38 U32.1
  BOTTOM w0.15: v1(122.1,114.38) 121.43,114.38 121.06,114.75
UNNAMED_6_PCF8574_I3_A1: length 3.5
  TOP w0.15: 123.27,113.03 123.25,113.05 v1(122.1,113.05) 121.8,113.35 121.06,113.35
  BOTTOM w0.15: v1(122.1,113.05) 121.37,113.05 121.06,113.35
UNNAMED_6_PCF8574_I3_A2: length 3.4
  TOP w0.15: 121.06,111.95 122,111.95 v1(122.1,111.85) 123.18,111.85 U32.3
  BOTTOM w0.15: v1(122.1,111.85) 121.16,111.85 121.06,111.95
UNNAMED_6_RESISTOR_I107_B: length 1
  BOTTOM w0.15: R270.2 v1(163.56,86.48)
UNNAMED_7_2WAY-SPST_I62_B: length 6.8
  TOP w0.15: SW1.3 116.75,68.66 U14.1
UNNAMED_7_2WAY-SPST_I62_B_1: length 9.6
  TOP w0.15: SW1.4 116,70.45 116,73.55 116.75,74.31 U14.16
UNNAMED_7_3D3225_I154_OUT5: length 8
  TOP w0.15: U5.1 134.95,75.1 135.4,74.65 138.6,74.65 139.31,73.94 U8.5
UNNAMED_7_65LVDS116_I76_A: length 61.9
  TOP w0.15: R21.2 87.7,86.48 87.47,86.72 U13.2 85.73,86.72 85.69,86.75 85.4,86.75 85.1,86.45 85.1,85.05 85.8,84.35 87.6,84.35 88.2,83.75 88.2,81.48 87.4,80.69 85.73,80.69 85.44,80.97 84.92,80.97 84.45,81.45 84,81.45 82.2,83.25 78.4,83.25 70.2,75.05 62.9,75.05 61,73.15 46.6,73.15 45.94,72.48 R269.2 44.49,73.1 U12.19
UNNAMED_7_65LVDS116_I76_B: length 62.1
  TOP w0.15: U12.20 44.49,73.6 R269.1 45.84,74.22 46.5,73.55 60.8,73.55 62.8,75.55 70.2,75.55 78.2,83.55 82.3,83.55 84.12,81.73 84.56,81.73 85.04,81.25 85.55,81.25 86.25,81.95 U10.8 87.41,81.95 87.8,82.35 87.8,83.55 87.4,83.95 85.7,83.95 84.7,84.95 84.7,87.55 85.1,87.95 85.69,87.95 85.73,87.98 U13.3 87.47,87.98 87.7,88.22 R21.1
UNNAMED_7_65LVDS116_I76_ENA: length 3.7
  TOP w0.15: U12.5 44.95,66.1 v1(45,66.15) R12.1
  BOTTOM w0.15: v1(45,66.15) R12.1
UNNAMED_7_65LVDS116_I76_ENB: length 3.7
  TOP w0.15: U12.10 44.95,68.6 v1(45,68.65) R10.1
  BOTTOM w0.15: R10.1 v1(45,68.65)
UNNAMED_7_65LVDS116_I76_ENC: length 4.3
  TOP w0.15: U12.23 44.85,75.1 v1(45.4,75.65) 46.34,75.65
  BOTTOM w0.15: v1(45.4,75.65) 46.34,75.65
UNNAMED_7_65LVDS116_I76_END: length 7
  TOP w0.15: 46.34,81.25 v1(45.4,81.25) 44.5,80.35 44.5,77.95 44.15,77.6 U12.28
  BOTTOM w0.15: v1(45.4,81.25) 46.34,81.25
UNNAMED_7_65LVDS116_I76_S0: length 5
  TOP w0.15: 46.34,77.05 v1(45.4,77.05) 45.4,76.45 44.55,75.6 U12.24
  BOTTOM w0.15: 46.34,77.05 v1(45.4,77.05)
UNNAMED_7_65LVDS116_I76_S1: length 5.8
  TOP w0.15: U12.25 44.35,76.1 44.8,76.55 44.8,77.32 45.4,77.92 v1(45.4,78.45) 46.34,78.45
  BOTTOM w0.15: v1(45.4,78.45) 46.34,78.45
UNNAMED_7_65LVDS116_I76_SM: length 6.6
  TOP w0.15: U12.26 44.2,76.6 44.5,76.9 44.5,77.45 44.8,77.75 44.8,79.25 v1(45.4,79.85) 46.34,79.85
  BOTTOM w0.15: 46.34,79.85 v1(45.4,79.85)
UNNAMED_7_74LVC1G06_I51_A: length 2
  TOP w0.15: U11.2 130.1,75.85 130.35,75.6 U5.7
UNNAMED_7_74LVC1G06_I51_Y: length 12.7
  TOP w0.15: TP14.1 120.9,69.84 120.56,70.18 120.56,72.6 123.12,75.15 125.7,75.15 127.06,76.51 U11.4
UNNAMED_7_DS90LV001_I121_EN: length 1.6
  TOP w0.15: U13.8 80.34,85.44 80.33,85.45 R23.1
UNNAMED_7_DS90LV018A_I104_RIN1: length 18.5
  TOP w0.15: TP11.1 101.06,86.91 R4.2 99.6,86.72 U6.2 97.75,86.72 97.19,86.15 95.7,86.15 92.2,82.65 90.8,82.65 87.56,79.41 U10.6
UNNAMED_7_DS90LV018A_I104_RIN1_: length 18.5
  TOP w0.15: TP10.1 100.61,85.15 100.57,85.19 99.8,85.19 99.54,85.44 U6.1 97.23,85.44 96.92,85.75 95.8,85.75 92.4,82.35 91.09,82.35 86.88,78.15 86.57,78.15
UNNAMED_7_DS90LV018A_I104_ROUT1: length 1.7
  TOP w0.15: R5.1 91.8,86.78 91.87,86.72 U6.7
UNNAMED_7_HEADER2X1_I125_B: length 7.8
  TOP w0.15: U3.4 97.12,75.33 96.8,75 96.8,73.05 97.2,72.65 97.24,72.65 PL2.2
UNNAMED_7_HEADER2X1_I126_B: length 7.6
  TOP w0.15: PL3.2 96.9,71.65 96.4,72.15 96.4,75.55 96.81,75.96 U3.5
UNNAMED_7_HEADER2X1_I127_B: length 13.7
  TOP w0.15: U3.19 94.21,79.14 95.1,78.25 95.1,72.55 94.1,71.55 92.46,71.55 PL4.2
UNNAMED_7_HEADER2X1_I149_B: length 3.4
  TOP w0.15: U16.1 113.65,77.81 113.7,77.76 PL6.2
UNNAMED_7_HEADER2X1_I150_B: length 5.7
  TOP w0.15: PL7.2 110.7,78.55 112.88,80.72 U16.2
UNNAMED_7_HEADER2X1_I151_B: length 3.4
  TOP w0.15: PL5.2 107.7,77.76 107.75,77.81 U16.16
UNNAMED_7_ICS527-01_I67_CLK1: length 1.9
  TOP w0.15: R3.1 91.43,77.25 91.45,77.23 U3.22
UNNAMED_7_ICS527-01_I67_OECLK2: length 2.3
  TOP w0.15: R2.2 100.03,79.91 99.26,79.14 U3.10
UNNAMED_7_ICS580-01_I60_CLK1: length 9.6
  TOP w0.15: U14.14 119.3,79.55 119.3,79.56 TP17.1 117.47,82.48 115.18,82.48 114.72,82.03 U16.4
UNNAMED_7_ICS581-02_I30_CLK2: length 1.8
  TOP w0.15: R30.1 106.44,82.03 U16.13
UNNAMED_7_ICS581-02_I30_CLK3: length 1.9
  TOP w0.15: 107.75,82.67 106.64,82.67 R31.1
UNNAMED_7_ICS581-02_I30_CLK4: length 6.2
  TOP w0.15: U16.11 110.28,83.33 110.92,83.97 U16.7
UNNAMED_7_ICS581-02_I30_INB: length 3.9
  TOP w0.15: 113.65,82.67 114.42,82.67 115.7,83.95 U15.3
UNNAMED_7_ICS581-02_I30_OE1: length 1.8
  TOP w0.15: U16.9 106.96,84.62 106.73,84.85 R29.1
UNNAMED_7_OSC-SMD_I36_EN: length 2.2
  TOP w0.15: R22.1 U15.1
UNNAMED_8_65LVDS116_I16_ENA: length 3.7
  TOP w0.15: R70.1 v1(45,90.15) 44.95,90.1 U17.5
  BOTTOM w0.15: v1(45,90.15) R70.1
UNNAMED_8_65LVDS116_I16_ENB: length 3.7
  TOP w0.15: U17.10 44.95,92.6 v1(45,92.65) R68.1
  BOTTOM w0.15: R68.1 v1(45,92.65)
UNNAMED_8_65LVDS116_I16_ENC: length 4.3
  TOP w0.15: 46.34,99.65 v1(45.4,99.65) 44.85,99.1 U17.23
  BOTTOM w0.15: v1(45.4,99.65) 46.34,99.65
UNNAMED_8_65LVDS116_I16_END: length 7
  TOP w0.15: 46.34,105.25 v1(45.4,105.25) 44.5,104.35 44.5,101.95 44.15,101.6 U17.28
  BOTTOM w0.15: v1(45.4,105.25) 46.34,105.25
UNNAMED_8_65LVDS116_I16_S0: length 5
  TOP w0.15: U17.24 44.55,99.6 45.4,100.45 v1(45.4,101.05) 46.34,101.05
  BOTTOM w0.15: 46.34,101.05 v1(45.4,101.05)
UNNAMED_8_65LVDS116_I16_S1: length 5.8
  TOP w0.15: 46.34,102.45 v1(45.4,102.45) 45.4,101.92 44.8,101.32 44.8,100.55 44.35,100.1 U17.25
  BOTTOM w0.15: v1(45.4,102.45) 46.34,102.45
UNNAMED_8_65LVDS116_I16_SM: length 6.6
  TOP w0.15: 46.34,103.85 v1(45.4,103.85) 44.8,103.25 44.8,101.75 44.5,101.45 44.5,100.9 44.2,100.6 U17.26
  BOTTOM w0.15: 46.34,103.85 v1(45.4,103.85)
UNNAMED_8_RESISTOR_I44_B: length 4.8
  BOTTOM w0.15: SK4.LRLA_A 3.13,130.05 4.6,130.05 4.9,129.75 R33.2
UNNAMED_8_RESISTOR_I45_B: length 4.8
  BOTTOM w0.15: SK4.LLLB_A 2.95,127.75 5,127.75 5.5,128.25 R34.2
UNNAMED_8_RESISTOR_I46_B: length 5
  BOTTOM w0.15: R36.2 5.4,114.75 4.8,115.35 3.23,115.35 SK4.LRLB_A
UNNAMED_8_RESISTOR_I47_B: length 4.6
  BOTTOM w0.15: SK4.LLLC_A 2.85,113.05 4.9,113.05 5.1,113.25 R38.2
UNNAMED_8_RESISTOR_I48_B: length 4.9
  BOTTOM w0.15: SK4.LRLC_A 3.22,100.75 4.9,100.75 5.4,100.25 R40.2
UNNAMED_8_RESISTOR_I49_B: length 4.7
  BOTTOM w0.15: R41.2 5.2,98.75 4.9,98.45 2.86,98.45 SK4.LLLD_A
UNNAMED_8_RESISTOR_I50_B: length 4.9
  BOTTOM w0.15: SK4.LRLD_A 3.22,86.15 4.9,86.15 5.3,85.75 R42.2
UNNAMED_8_RESISTOR_I51_B: length 4.7
  BOTTOM w0.15: SK4.LLLE_A 2.87,83.85 4.9,83.85 5.3,84.25 R43.2
UNNAMED_8_RESISTOR_I52_B: length 4.8
  BOTTOM w0.15: R44.2 5.3,71.25 4.9,71.65 3.11,71.65 SK4.LRLE_A
UNNAMED_8_RESISTOR_I53_B: length 4.8
  BOTTOM w0.15: SK4.LLLF_A 2.97,69.35 5,69.35 5.4,69.75 R45.2
UNNAMED_8_RESISTOR_I54_B: length 4.8
  BOTTOM w0.15: R46.2 3.41,56.75 SK4.LRLF_A
UNNAMED_8_RESISTOR_I55_B: length 4.8
  BOTTOM w0.15: SK4.LLLG_A 2.97,54.75 5.1,54.75 5.6,55.25 R47.2
UNNAMED_8_RESISTOR_I56_B: length 4.7
  BOTTOM w0.15: R48.2 3.3,42.25 SK4.LRLG_A
UNNAMED_8_RESISTOR_I57_B: length 4.9
  BOTTOM w0.15: R49.2 5.6,40.75 5,40.15 2.98,40.15 SK4.LLLH_A
UNNAMED_8_RESISTOR_I58_B: length 4.7
  BOTTOM w0.15: SK4.LRLH_A 3.2,27.75 R50.2
UNNAMED_8_RESISTOR_I59_B: length 4.6
  BOTTOM w0.15: SK4.LLLA_A 2.97,140.25 R32.2
UNNAMED_8_RESISTOR_I60_A: length 1.6
  BOTTOM w0.15: R51.1 5.37,141.25 5.31,141.31 4.44,141.31
UNNAMED_8_RESISTOR_I61_A: length 1.8
  BOTTOM w0.15: R52.1 4.97,130.75 4.44,131.28
UNNAMED_8_RESISTOR_I62_A: length 1.9
  BOTTOM w0.15: R53.1 4.99,127.25 4.44,126.71
UNNAMED_8_RESISTOR_I63_A: length 2
  BOTTOM w0.15: 4.44,116.67 5.37,115.75 R54.1
UNNAMED_8_RESISTOR_I64_A: length 1.7
  BOTTOM w0.15: R55.1 5.6,112.25 5.45,112.1 4.44,112.1
UNNAMED_8_RESISTOR_I65_A: length 2
  BOTTOM w0.15: R56.1 5.26,101.25 4.44,102.07
UNNAMED_8_RESISTOR_I66_A: length 1.7
  BOTTOM w0.15: R57.1 5.56,97.75 5.31,97.5 4.44,97.5
UNNAMED_8_RESISTOR_I67_A: length 1.9
  BOTTOM w0.15: R58.1 5.16,86.75 4.44,87.46
UNNAMED_8_RESISTOR_I68_A: length 1.8
  BOTTOM w0.15: 4.44,82.89 5.31,82.89 5.67,83.25 R59.1
UNNAMED_8_RESISTOR_I69_A: length 1.9
  BOTTOM w0.15: 4.44,72.86 5.05,72.25 R60.1
UNNAMED_8_RESISTOR_I70_A: length 1.8
  BOTTOM w0.15: 4.44,68.29 5.34,68.29 5.8,68.75 R61.1
UNNAMED_8_RESISTOR_I71_A: length 1.8
  BOTTOM w0.15: R64.1 5.7,43.25 5.3,43.65 4.45,43.65 4.44,43.65
UNNAMED_8_RESISTOR_I72_A: length 1.9
  BOTTOM w0.15: 4.44,39.08 5.12,39.75 R65.1
UNNAMED_8_RESISTOR_I73_A: length 1.7
  BOTTOM w0.15: R66.1 5.6,28.75 5.31,29.04 4.44,29.04
UNNAMED_8_RESISTOR_I74_A: length 1.8
  BOTTOM w0.15: 4.44,58.25 4.45,58.25 5.3,58.25 5.8,57.75 R62.1
UNNAMED_8_RESISTOR_I75_A: length 1.9
  BOTTOM w0.15: 4.44,53.68 5.01,54.25 R63.1
UNNAMED_8_RESISTOR_I135_B: length 2.8
  TOP w0.15: v1(98.5,135.97) 98.8,136.26 U59.23
  BOTTOM w0.15: v1(98.5,135.97) 97.55,135.97 R271.2
UNNAMED_8_RESISTOR_I136_B: length 2.8
  TOP w0.15: v1(98.5,42.27) 98.8,42.56 100.05,42.56
  BOTTOM w0.15: R272.2 97.55,42.27 v1(98.5,42.27)
UNNAMED_10_CAPACITOR_I14_B: length 6.5
  TOP w0.15: R165.2 v1(56.23,40.25) 56.23,41.12 C103.2 57.77,41.25 R164.1 58.13,41.62 U36.3
  BOTTOM w0.15: R165.2 v1(56.23,40.25)
UNNAMED_10_CAPACITOR_I15_B: length 6.5
  TOP w0.15: U36.2 58.13,42.88 R164.2 57.77,43.25 C102.2 56.23,43.38 v1(56.23,44.25) R163.1
  BOTTOM w0.15: R163.1 v1(56.23,44.25)
UNNAMED_10_CAPACITOR_I30_B: length 6.5
  TOP w0.15: R170.2 v1(56.23,61.65) 56.23,62.52 C105.2 57.77,62.65 R169.1 58.13,63.02 U37.3
  BOTTOM w0.15: R170.2 v1(56.23,61.65)
UNNAMED_10_CAPACITOR_I31_B: length 6.5
  TOP w0.15: U37.2 58.13,64.28 R169.2 57.77,64.65 C104.2 56.23,64.78 v1(56.23,65.65) R168.1
  BOTTOM w0.15: R168.1 v1(56.23,65.65)
UNNAMED_10_CAPACITOR_I61_B: length 6.5
  TOP w0.15: R183.2 v1(56.23,29.55) 56.23,30.42 C117.2 57.77,30.55 R182.1 58.13,30.91 U40.3
  BOTTOM w0.15: R183.2 v1(56.23,29.55)
UNNAMED_10_CAPACITOR_I62_B: length 6.5
  TOP w0.15: R181.1 v1(56.23,33.55) 56.23,32.68 C116.2 57.77,32.55 R182.2 58.13,32.19 U40.2
  BOTTOM w0.15: R181.1 v1(56.23,33.55)
UNNAMED_10_CAPACITOR_I79_B: length 6.5
  TOP w0.15: U41.3 58.13,52.31 57.77,51.95 C119.2 56.23,51.82 v1(56.23,50.95) R186.2
  BOTTOM w0.15: R186.2 v1(56.23,50.95)
UNNAMED_10_CAPACITOR_I80_B: length 6.5
  TOP w0.15: U41.2 58.13,53.59 R185.2 57.77,53.95 C118.2 56.23,54.08 v1(56.23,54.95) R184.1
  BOTTOM w0.15: R184.1 v1(56.23,54.95)
UNNAMED_10_DS90LV001_I18_EN: length 1.8
  TOP w0.15: U36.8 64.97,45.15 65.06,45.25 R173.1
UNNAMED_10_DS90LV001_I38_EN: length 1.8
  TOP w0.15: R177.1 v1(59.53,44.98)
  BOTTOM w0.15: v1(59.53,44.98) 59.53,44.25 U38.8
UNNAMED_10_DS90LV001_I38_OUT: length 3.2
  TOP w0.15: v1(58.3,40.25) 58.3,39.59 R165.1
  BOTTOM w0.15: U38.6 59.32,41.62 58.68,40.98 58.68,40.63 v1(58.3,40.25)
UNNAMED_10_DS90LV001_I38_OUT_1: length 3.2
  TOP w0.15: R163.2 58.3,44.91 v1(58.3,44.25)
  BOTTOM w0.15: U38.7 59.32,42.88 58.68,43.52 58.68,43.87 v1(58.3,44.25)
UNNAMED_10_DS90LV001_I39_EN: length 1.8
  TOP w0.15: R174.1 65.06,66.65 64.97,66.55 U37.8
UNNAMED_10_DS90LV001_I43_EN: length 1.8
  TOP w0.15: R178.1 v1(59.53,66.39)
  BOTTOM w0.15: U39.8 59.53,65.65 v1(59.53,66.39)
UNNAMED_10_DS90LV001_I43_OUT: length 3.2
  TOP w0.15: v1(58.3,61.65) 58.3,60.98 R170.1
  BOTTOM w0.15: U39.6 59.32,63.02 58.68,62.38 58.68,62.03 v1(58.3,61.65)
UNNAMED_10_DS90LV001_I43_OUT_1: length 3.2
  TOP w0.15: v1(58.3,65.65) 58.3,66.31 R168.2
  BOTTOM w0.15: U39.7 59.32,64.28 58.68,64.92 58.68,65.27 v1(58.3,65.65)
UNNAMED_10_DS90LV001_I68_EN: length 1.8
  TOP w0.15: R191.1 65.06,34.55 64.97,34.45 U40.8
UNNAMED_10_DS90LV001_I85_EN: length 1.8
  TOP w0.15: U41.8 64.97,55.85 65.06,55.95 R192.1
UNNAMED_10_DS90LV001_I90_EN: length 1.8
  TOP w0.15: R195.1 v1(59.53,34.28)
  BOTTOM w0.15: v1(59.53,34.28) 59.53,33.55 U42.8
UNNAMED_10_DS90LV001_I90_OUT: length 3.2
  TOP w0.15: v1(58.3,29.55) 58.3,28.88 R183.1
  BOTTOM w0.15: U42.6 59.32,30.91 58.68,30.28 58.68,29.93 v1(58.3,29.55)
UNNAMED_10_DS90LV001_I90_OUT_1: length 3.2
  TOP w0.15: v1(58.3,33.55) 58.3,34.22 R181.2
  BOTTOM w0.15: v1(58.3,33.55) 58.68,33.17 58.68,32.82 59.32,32.19 U42.7
UNNAMED_10_DS90LV001_I94_EN: length 1.8
  TOP w0.15: R196.1 v1(59.53,55.69)
  BOTTOM w0.15: v1(59.53,55.69) 59.53,54.95 U43.8
UNNAMED_10_DS90LV001_I94_OUT: length 3.2
  TOP w0.15: R186.1 58.3,50.28 v1(58.3,50.95)
  BOTTOM w0.15: U43.6 59.32,52.31 58.68,51.68 58.68,51.33 v1(58.3,50.95)
UNNAMED_10_DS90LV001_I94_OUT_1: length 3.2
  TOP w0.15: v1(58.3,54.95) 58.3,55.61 R184.2
  BOTTOM w0.15: v1(58.3,54.95) 58.68,54.57 58.68,54.22 59.32,53.59 U43.7
USD_LED: length 4.4
  TOP w0.15: R145.1 134.47,106.55 134.34,106.67 U32.10 v1(131.62,106.67)
  BOTTOM w0.15: DS6.2 v1(6.57,4.42)
WP: length 13.3
  TOP w0.15: U32.12 135,109.22 R147.1 135.13,109.39 136,110.25 137.8,110.25 141.47,113.92 U34.7

## Copper pours and planes (outline as drawn)
ESD_SEGMENT_1 on BOTTOM: 154,0.3 154,1.3 144,1.3 144,0.3
ESD_SEGMENT_2 on BOTTOM: 141,0.3 141,1.3 131,1.3 131,0.3
ESD_SEGMENT_3 on BOTTOM: 128,0.3 128,1.3 18.25,1.3 18.25,0.3

## Text on the board
BOTTOM: J
Package Geometry/Pastemask Bottom: PCXXXXM ISSUE X X FACE ,BOTTOM SOLDER PASTE
User.Comments: PCXXXXM ISSUE X X FACE , BOTTOM SOLDER RESIST | PCXXXXM ISSUE X X FACE , TOP SOLDER RESIST | X     SOLDER RESIST - TOP             MOSTLY RESIST | Y     SOLDER RESIST - BOTTOM          MOSTLY RESIST | A     15-04-11      -----     D.J.BECKETT   C.P.DAY      E.MOTUK | 1:1 | XFEL | CC PRE-PROTOTYPE B | 50 | PC3462M | NOT FOR MANUFACTURE | PROVISIONAL DATA
TOP: A
Package Geometry/Pastemask Top: PCXXXXM ISSUE X X FACE , TOP SOLDER PASTE
POWER: B
INNER TRACKS 1: C
POWER/GND1: D
INNER TRACKS 2: E
INNER TRACKS 3: F
POWER/GND2: G
INNER TRACKS 4: H
GND: I
BODY_CENTER: STFC-RAL | MAY 2011 | M | V     COMPONENT IDENT - TOP | PRE-PROTOTYPE B | XFEL CC
DISPLAY_TOP: W     COMPONENT IDENT - BOTTOM | N
PLACE_BOUND_TOP: LAYER | TRACK | WIDTH | MIN. GAP | Zo | REF:  LAYER/LAYERS | NOTE: ODB++ DATA USED | x                        x&y (STRIPLINE) | x                        x (MICROSTRIP) | @ DIFFERENTIAL IMPEDANCE OF xx OHMS REQUIRED BETWEEN | # DIFFERENTIAL IMPEDANCE OF xx OHMS REQUIRED BETWEEN | BY A yyyum GAP | PAIRS OF xxxum TRACKS RUNNING IN PARALLEL SEPERATED | x                        # SEE BELOW | x                        @ SEE BELOW | TOOL    SYMBOL    SIZE(mm)    PLATED    QTY | T01 | T02 | T03 | T04 | T05 | T06 | T07 | T08 | T09 | T10 | T11 | T12 | T13 | T14 | T15 | T16 | T17 | X     COMPONENT IDENT. - TOP | X     SOLDER RESIST -TOP | A     TOP TRACKS | X     PLANE | X     INNER TRACKS 1 | X     INNER TRACKS 2 | X     INNER TRACKS 3 | X     INNER TRACKS 4 | X     INNER TRACKS 5 | X     INNER TRACKS 6 | X     INNER TRACKS 7 | X     INNER TRACKS 8 | X     BOTTOM TRACKS | X     SOLDER RESIST - BOTTOM | X     COMPONENT IDENT. - BOTTOM | DESCRIPTION | SEE IMPEDANCE TABLE | COMMENT | 6. COPPER FILL MAY BE ADDED TO ASSIST WITH A MORE BALANCED BUILD. | 5. ACCEPTABLE BOARD BOW/TWIST: 0.75% OR LESS ACROSS THE DIAGONAL | CONSULT ENGINEER IF THIS IS NECESSARY. | HOLES +/- 0.05 mm | GENERAL +/- 0.1 mm | SEE NOTES | 1 | HOLE SIZES (FINISHED) | LAYER STRUCTURE | 005 00 A | PC3462M       ISSUE 1 | MASTER
DISPLAY_BOTTOM: AREA FOR HOT | SWAP SWITCH | AND ACTUATOR | RECOMMENDED | RESERVED | OPTIONAL AREA FOR | FACE PLATE MOUNTING | HARDWARE | RESERVED AREA FOR | EXCLUSION AREA - CARD GUIDES
USER_PART_NUM_TOP: 2 | 3. MOUNT GROUND BARS AS HIGH OFF OF THE BOARD AS POSSIBLE (LK**). | 2. NOTE - LINKS MARKED WITH LC** AND/OR LO** ARE NOT PHYSICAL COMPONENTS AND NEED NO ASSEMBLY. | SOLDER PASTE MASTERS AVAILABLE FOR ASSEMBLY OF SURFACE MOUNT COMPONENTS. | BOTTOM SOLDER PASTE - PC3462M/1 P FACE | BOTTOM ASSEMBLY DRG. AVAILABLE - A2-TE-0156-005-02-A | 1. ENSURE CORRECT ORIENTATION OF COMPONENTS AND FIT WITH VALUES | TOP SOLDER PASTE - PC3462M/1 O FACE | VISIBLE WHERE POSSIBLE. | ASSEMBLY NOTES | BOARD VIEWED ON PRIMARY SIDE - A FACE/COMPONENT SIDE 1 | 006 01 A | TOP ASSEMBLY
PAGE_OUTLINE: 2 | 2. NOTE - LINKS MARKED WITH LC** AND/OR LO** ARE NOT PHYSICAL COMPONENTS AND NEED NO ASSEMBLY. | SOLDER PASTE MASTERS AVAILABLE FOR ASSEMBLY OF SURFACE MOUNT COMPONENTS. | TOP SOLDER PASTE - PC3462M/1 O FACE | BOTTOM SOLDER PASTE - PC3462M/1 P FACE | TOP ASSEMBLY DRG. AVAILABLE - A2-TE-0156-005-02-A | 1. ENSURE CORRECT ORIENTATION OF COMPONENTS AND FIT WITH VALUES | VISIBLE WHERE POSSIBLE. | ASSEMBLY NOTES | BOARD VIEWED ON 'Z' FACE | 006 02 A | BOTTOM ASSEMBLY
User.10: PC3462M/1
User.11: PC3462M/1
User.12: CENTRE LINE | 1A | 0,0
